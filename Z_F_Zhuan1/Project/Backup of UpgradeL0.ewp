# IAR project Backup of UpgradeL0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031K4 ST STM32L031K4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L031xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Source\APP\inc; ..\Source\BSP\inc; ..\Source\CMSIS; ..\Source\FWLib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UpgradeL0.bin
  ILINK.IlinkOutputFile: UpgradeL0.out
  ILINK.IlinkIcfFile: E:\工作工程\温湿度\UpgradeCarL031x4\Project\stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../Source/APP/: main.c modbus_asc.c modbus_ascii.c para.c
  group BSP
    ../Source/BSP/: adc.c eeprom.c FlashIf.c usart.c
  group CMSIS
    ../Source/CMSIS/: startup_stm32l031xx.s system_stm32l0xx.c
  group FWLib
    ../Source/FWLib/src/: stm32l0xx_hal.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
