# Keil uVision project zheng.uvprojx, settings and files
target zheng (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L031F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: zheng +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L031xx
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\APP\inc;..\APP;..\BSP\inc;..\BSP;..\RT-Thread\components\finsh;..\RT-Thread\include\libc;..\RT-Thread\libcpu;..\RT-Thread\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l031xx.s
  group Application/User
    ../APP/: main.c common.c modbus_asc.c modbus_ascii.c para.c stm32l0xx_hal_msp.c board.c rtconfig.h system.c
  group BSP
    ../BSP/: adc.c eeprom.c tim.c usart.c led.c task.c
  group RT-Thread/Kernel
    ../RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread/Ports
    ../RT-Thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group RT-Thread/Finish
    ../RT-Thread/components/finsh/: cmd.c msh.c shell.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_iwdg.c
  group Drivers/CMSIS
    ../APP/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
