# IAR project zheng.ewp, settings and files
configuration zheng (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031F4 ST STM32L031F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L031xx
  ICCARM.CCIncludePath2: E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\APP\inc; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\BSP\inc; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\Drivers\STM32L0xx_HAL_Driver\Inc; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\Drivers\CMSIS\Device\ST\STM32L0xx\Include; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\Drivers\CMSIS\Include; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\APP; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\BSP; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\APP\inc; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\BSP\inc; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\RT-Thread\components\finsh; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\RT-Thread\src; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\RT-Thread\include\libc; E:\STM32\STM32MXCUBE\Z_F_Zhuan-RTT_nano\RT-Thread\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zheng.hex
  ILINK.IlinkOutputFile: zheng.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../APP/: board.c common.c main.c modbus_asc.c modbus_ascii.c para.c rtconfig.h system.c
  group BSP
    ../BSP/: adc.c eeprom.c led.c task.c tim.c usart.c
  group Drivers/CMSIS
    ./: startup_stm32l031xx.s
    ../APP/: system_stm32l0xx.c
  group Drivers/STM32LOxx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
  group RT-Thread/Finish
    ../RT-Thread/components/finsh/: cmd.c msh.c shell.c
  group RT-Thread/Kernel
    ../RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread/Ports
    ../RT-Thread/libcpu/arm/cortex-m0/: context_iar.S cpuport.c
