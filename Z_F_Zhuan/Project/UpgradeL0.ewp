# IAR project UpgradeL0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031F4 ST STM32L031F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L031xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: D:\github\wireless\direct-sensor\APP\inc; D:\github\wireless\direct-sensor\BSP\inc; D:\github\wireless\direct-sensor\CMSIS; D:\github\wireless\direct-sensor\FWLib\inc; D:\github\wireless\direct-sensor\Z_F_Zhuan\APP\inc; D:\github\wireless\direct-sensor\Z_F_Zhuan\BSP\inc; D:\github\wireless\direct-sensor\Z_F_Zhuan\CMSIS; D:\github\wireless\direct-sensor\Z_F_Zhuan\FWLib\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DirectionSensor_rotation1.0.1.bin
  ILINK.IlinkOutputFile: WorkTime_L031_F3.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: common.c main.c modbus_asc.c modbus_ascii.c para.c
  group BSP
    ../BSP/: adc.c eeprom.c FlashIf.c tim.c usart.c
  group CMSIS
    ../CMSIS/: startup_stm32l031xx.s system_stm32l0xx.c
  group FWLib
    ../FWLib/src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
